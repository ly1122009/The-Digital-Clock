# Keil uVision project Emb07_Mock_NguyenCongLy.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Emb07_Mock_NguyenCongLy
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HAxxxLLx\S32K144_64_flash.sct
  group Source Group 1
    ./: main.c GPIO.h LPSPI.h LPUART.h NVIC.h PCC.h PORT.h Prototype.h SCG.h Systick.h Timer.h Prototype.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.0.0
